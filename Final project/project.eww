<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\..\..\Lab\Lab 10 A\Lab 10 A.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\Project.ewp</path>
    </project>
    <batchBuild />
</workspace>
